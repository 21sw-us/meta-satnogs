PACKAGECONFIG_class-native += "cairo"
